# IAR project audio_mic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G457QE Nations N32G457QE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G45X; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT=1
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc; ..\..\..\..\..\..\firmware\n32g45x_usbfs_driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: audio_mic.bin
  ILINK.IlinkOutputFile: audio_mic.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_dac.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c
  group n32g45x_usbfs_driver
    ../../../../../../firmware/n32g45x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x_EWARM.s
  group USER
    ../src/: delay.c hw_config.c main.c n32g45x_it.c recorder.c spi.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c vs10xx.c

# Keil uVision project keyboard.uvprojx, settings and files
target N32G45x (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HID_Keyboard +hex
  AfterMake: fromelf --bin --output=.\bin\HID_Keyboard.bin .\Objects\HID_Keyboard.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\HID_Keyboard.axf --output=.\bin\HID_Keyboard.dua
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\..\..\..\..\..\firmware\n32g45x_usbfs_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_usart.c n32g45x_dbg.c n32g45x_pwr.c
  group USER
    ../src/: main.c n32g45x_it.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group DOC
    ../: readme.txt
  group n32g45x_usbfs_driver
    ../../../../../../firmware/n32g45x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c

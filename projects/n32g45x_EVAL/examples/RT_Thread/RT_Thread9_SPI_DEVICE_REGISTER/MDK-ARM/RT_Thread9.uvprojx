# Keil uVision project RT_Thread9.uvprojx, settings and files
target N32G45x (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT_Thread9 +hex
  AfterMake: fromelf --bin --output=.\bin\RT_Thread9.bin .\Objects\RT_Thread9.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,RT_USING_EVENT,RT_USING_MUTEX
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\app\inc;..\..\DeviceDrivers\inc;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\spi\inc;..\..\DeviceDrivers\spi\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_exti.c n32g45x_usart.c n32g45x_spi.c
  group APP
    ../app/src/: application.c main.c n32g45x_it.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c components.c cpu.c signal.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group BSP
    ../../DeviceDrivers/src/: bsp.c log.c
  group DOC
    ../: readme.txt
  group DeviceDrivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c pin.c
    ../../DeviceDrivers/spi/src/: drv_spi.c spi_core.c spi_dev.c spi_flash.c spi_flash_sfud.c
    ../../DeviceDrivers/spi/sfud/src/: sfud.c sfud_sfdp.c

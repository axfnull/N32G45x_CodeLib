# Keil uVision project SPI_RECORDER.uvprojx, settings and files
target N32G45x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI_CODEC +hex
  AfterMake: fromelf --bin --output=.\bin\SPI_CODEC.bin .\Objects\SPI_CODEC.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_spi.c n32g45x_usart.c
  group USER
    ../src/: n32g45x_it.c spi_flash.c vs10xx.c recorder.c key.c main.c spi.c delay.c
  group MALLOC
    ../src/: malloc.c
  group DOC
    ../: readme.txt

# Keil uVision project iCache_CoreMark_Proj.uvprojx, settings and files
target N32G45x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iCache_CoreMark_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\iCache_CoreMark_Proj.bin .\Objects\iCache_CoreMark_Proj.axf
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER, SYSCLK_FREQ=144000000
  c include: ..\inc;..\coremark;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_wwdg.c
  group USER
    ../src/: main.c n32g45x_it.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../: readme.txt
target SRAM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.2
  cpu: as above
  output: iCache_CoreMark_Proj +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER, SYSCLK_FREQ=32000000, VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10010000 size 0x14000

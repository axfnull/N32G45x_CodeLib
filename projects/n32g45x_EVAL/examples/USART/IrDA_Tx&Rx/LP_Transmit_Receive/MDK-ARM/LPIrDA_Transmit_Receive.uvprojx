# Keil uVision project LPIrDA_Transmit_Receive.uvprojx, settings and files
target N32G45x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPIrDA_Transmit_Receive +hex
  AfterMake: fromelf --bin --output=.\bin\LPIrDA_Transmit_Receive.bin .\Objects\LPIrDA_Transmit_Receive.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\LPIrDA_Transmit_Receive.axf --output=.\bin\LPIrDA_Transmit_Receive.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,SYSCLK_FREQ=8000000,SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  c include: ..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_dma.c
  group USER
    ../src/: main.c n32g45x_it.c bsp_Tim_38K.c
  group DOC
    ../: readme.txt

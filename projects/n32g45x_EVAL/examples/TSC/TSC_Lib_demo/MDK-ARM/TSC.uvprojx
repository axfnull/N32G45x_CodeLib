# Keil uVision project TSC.uvprojx, settings and files
target N32G45X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X USE_STDPERIPH_DRIVER,BD_RTC_USE_LSI
  c misc: --wchar32
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\TSC_Lib.sct
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group Driver
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: n32g45x_bkp.c n32g45x_dbg.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c misc.c
  group User
    ../src/: main.c bsp_usart.c bsp_gpio.c bsp_it.c bsp_timer.c bsp_tsc.c rtc_hal.c
    ../../../../../../firmware/n32g45x_std_periph_driver/inc/: n32xx_tsc_alg_api.h n32xx_tsc_alg_api.lib
  group DOC
    ../: readme.txt
